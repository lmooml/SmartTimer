# Keil uVision project timertest.uvproj, settings and files
target timertest (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: timertest +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\app;.\fwlib\STM32F10x_StdPeriph_Driver\inc;.\fwlib\CMSIS\Include;.\fwlib\CMSIS\Device\ST\STM32F10x\Include;..\smarttimer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./app/: main.c stm32_it.c stm32f10x_conf.h
    ../smarttimer/: smarttimer.c
  group lib
    ./fwlib/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
    ./fwlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ./fwlib/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
