# Keil uVision project demo.uvproj, settings and files
target Demo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\app;.\fwlib\STM32F10x_StdPeriph_Driver\inc;.\fwlib\CMSIS\Include;.\fwlib\CMSIS\Device\ST\STM32F10x\Include;..\smarttimer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./app/: main.c stm32_it.c
    ../smarttimer/: smarttimer.c
  group fwlib
    ./fwlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ./fwlib/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
    ./fwlib/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
